inherit core-image
IMAGE_INSTALL_append = " rootfsoverlay"
