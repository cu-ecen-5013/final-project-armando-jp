inherit core-image
IMAGE_INSTALL_append = " meta-finalprojectserver"
CORE_IMAGE_EXTRA_INSTALL += " openssh"
